# Keil uVision project Test_SDK_2_0.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7 ARM
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: Test_SDK_2_0
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group COMMON
    ./: main.c
    ./COMMON/: init.c interrupt.c debug_out.c
  group DRIVERS
    ./DRIVER/: systimer.c eth.c eth_mii_phy.c serial.c
  group STARTUP
    ./STARTUP/: Startup.s
